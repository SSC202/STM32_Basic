<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\MX25LM51245G_STM32L4R9I-DISCO.ewp</path>
  </project>
  <batchBuild/>
</workspace>


