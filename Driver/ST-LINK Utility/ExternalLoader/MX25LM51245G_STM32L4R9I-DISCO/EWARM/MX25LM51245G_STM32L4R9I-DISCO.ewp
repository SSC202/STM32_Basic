# IAR project MX25LM51245G_STM32L4R9I-DISCO.ewp, settings and files
configuration STM32L476G_EVAL (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; USE_IOEXPANDER; STM32L4R9xx; OCTOSPI
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\BSP\STM32L4R9I-Discovery; ..\..\..\..\..\..\Drivers\BSP\Components\mx25lm51245g
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MX25LM51245G_STM32L4R9I-DISCO.hex
  ILINK.IlinkOutputFile: MX25LM51245G_STM32L4R9I-DISCO-OSPI2.out
  ILINK.IlinkIcfFile: Target.icf
  ILINK.IlinkExtraOptions: --diag_suppress Lp005,Lp006
  ILINK.IlinkProgramEntryLabel: Init
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/BSP/STM32L4R9I-Discovery/: stm32l4r9i_discovery_ospi_nor.c
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_ospi.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c
  group Example/EWARM/User
    ../Src/: Dev_Inf.c Loader_Src.c stm32l4xx_hal_msp.c
