# IAR project N25Q256A_STM32L476G-EVAL.ewp, settings and files
configuration STM32L476G_EVAL (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; USE_IOEXPANDER; STM32F769xx; USE_STM32F769I_EVAL
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F7xx\Include; ..\..\..\..\..\..\Drivers\STM32F7xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\BSP\STM32F769I_EVAL; ..\..\..\..\..\..\Drivers\BSP\Components\n25q512a; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F7xx\Source\Templates; ..\..\..\..\..\..\Drivers\BSP\STM32F769I_EVAL
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: N25Q512A_STM32F769I-EVAL.hex
  postbuild: cmd.exe /C copy "N25Q256A_STM32L476G-EVAL\Exe\N25Q256A_STM32L476G-EVAL.out" "..\..\..\..\..\..\..\N25Q256A_STM32L476G-EVAL.stldr"
  ILINK.IlinkOutputFile: N25Q512A_STM32F769I-EVAL.out
  ILINK.IlinkIcfFile: Target.icf
  ILINK.IlinkProgramEntryLabel: Init
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/BSP/STM32F769I_EVAL/: stm32f769i_eval_qspi.c
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c
  group Example/EWARM/User
    ../Src/: Dev_Inf.c Loader_Src.c stm32f7xx_hal_msp.c
